# Keil uVision project project.uvprojx, settings and files
target ZQ_STM32F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c misc: --diag_suppress=870
  c include: ..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Utilities\Third_Party\lwip_v1.3.2\src\netif;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\arch;..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\Utilities\Third_Party\lwip_v1.3.2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.c netconf.c stm32f4x7_eth_bsp.c UDP_SERVER.C CHINESE.c I2C.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group LwIP
    ../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
